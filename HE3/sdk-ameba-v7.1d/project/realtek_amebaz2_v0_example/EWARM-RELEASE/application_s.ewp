# IAR project application_s.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8710C; __ARM_ARCH_8M_MAIN__=1; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; V8M_STKOVF; CONFIG_BUILD_SECURE=1; V8M_SECURE
  ICCARM.IExtraOptions: --cmse; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\lib\include; ..\..\..\component\soc\realtek\8710c\fwlib\include; ..\..\..\component\soc\realtek\8710c\fwlib\lib\include; ..\..\..\component\soc\realtek\8710c\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8710c\cmsis\rtl8710c\include; ..\..\..\component\soc\realtek\8710c\app\rtl_printf\include; ..\..\..\component\soc\realtek\8710c\app\shell; ..\..\..\component\soc\realtek\8710c\app\stdio_port; ..\..\..\component\soc\realtek\8710c\misc\utilities\include; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8710C\secure; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8710C\non_secure; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network\include; ..\..\..\component\common\application; ..\..\..\component\common\application\mqtt\MQTTClient; ..\..\..\component\common\example; ..\..\..\component\common\file_system; ..\..\..\component\common\file_system\dct; ..\..\..\component\common\utilities; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8710c; ..\..\..\component\soc\realtek\8710c\mbed-drivers\include; ..\..\..\component\os\os_dep\include; ..\..\..\component\common\network; ..\..\..\component\common\network\coap\include; ..\..\..\component\common\network\http2\nghttp2-1.31.0\includes; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\mbed\targets\hal\rtl8710c; ..\..\..\component\common\test
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: V8M_STKOVF; V8M_SECURE
  AARM.AUserIncludes: ..\inc; ..\..\..\component\soc\realtek\8710c\cmsis; ..\..\..\component\os\os_dep\include; ..\..\..\component\os\freertos\freertos_v10.0.1\Source\include; ..\..\..\component\os\freertos\freertos_v10.0.1\Source\portable\IAR\ARM_RTL8710C
  OBJCOPY.OOCOutputFile: application_s.srec
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\8710c\misc\iar_utility\postbuild_s.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$CONFIG_NAME$" "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: ram_start_s
  ILINK.IlinkIcfFile: application_s.icf
  ILINK.IlinkExtraOptions: --redirect malloc=__wrap_malloc; --redirect realloc=__wrap_realloc; --redirect free=__wrap_free; --redirect printf=__wrap_printf; --redirect sprintf=__wrap_sprintf; --redirect snprintf=__wrap_snprintf; --redirect vsnprintf=__wrap_vsnprintf; --redirect memcmp=__wrap_memcmp; --redirect memcpy=__wrap_memcpy; --redirect memmove=__wrap_memmove; --redirect memset=__wrap_memset; --redirect strcat=__wrap_strcat; --redirect strchr=__wrap_strchr; --redirect strcmp=__wrap_strcmp; --redirect strncmp=__wrap_strncmp; --redirect strnicmp=__wrap_strnicmp; --redirect strcpy=__wrap_strcpy; --redirect strncpy=__wrap_strncpy; --redirect strlcpy=__wrap_strlcpy; --redirect strlen=__wrap_strlen; --redirect strnlen=__wrap_strnlen; --redirect strncat=__wrap_strncat; --redirect strpbrk=__wrap_strpbrk; --redirect strspn=__wrap_strspn; --redirect strstr=__wrap_strstr; --redirect strtok=__wrap_strtok; --redirect strxfrm=__wrap_strxfrm; --redirect strsep=__wrap_strsep; --redirect strtod=__wrap_strtod; --redirect strtof=__wrap_strtof; --redirect strtold=__wrap_strtold; --redirect strtoll=__wrap_strtoll; --redirect strtoul=__wrap_strtoul; --redirect strtoull=__wrap_strtoull; --redirect atoi=__wrap_atoi; --redirect atoui=__wrap_atoui; --redirect atol=__wrap_atol; --redirect atoul=__wrap_atoul; --redirect atoull=__wrap_atoull; --redirect atof=__wrap_atof; --skip_dynamic_initialization; --keep hal_crypto_engine_init_platform_nsc
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group @ERAM/ssl_ext/mbedtls
    ../../../component/common/network/ssl/mbedtls-2.4.0/library/: arc4.c cipher.c cipher_wrap.c debug.c ecdh.c gcm.c ssl_ciphersuites.c ssl_cli.c x509.c x509_crt.c
    ../../../component/common/network/ssl/mbedtls-2.4.0/library_s/: mbedtls_ext_nsc.c
  group @SRAM
    ../../../component/common/file_system/ftl/: ftl_crypto.c
  group cmsis
    ../../../component/soc/realtek/8710c/cmsis/rtl8710c/source/ram_s/: app_start.c
    ../../../component/soc/realtek/8710c/misc/utilities/source/ram/: libc_wrap.c
    ../../../component/soc/realtek/8710c/cmsis/rtl8710c/source/ram/: mpu_config.c
  group console
    ../../../component/soc/realtek/8710c/app/shell/ram_s/: consol_cmds.c
  group lib
    ../../../component/soc/realtek/8710c/misc/bsp/lib/common/IAR/: lib_soc_s.a
  group network/ssl/mbedtls
    ../../../component/common/network/ssl/mbedtls-2.4.0/library/: aes.c asn1parse.c asn1write.c base64.c bignum.c ecdsa.c ecp.c ecp_curves.c md.c md5.c md_wrap.c oid.c pem.c pk.c pk_wrap.c pkparse.c platform.c rsa.c sha1.c sha256.c sha512.c ssl_tls.c
    ../../../component/common/network/ssl/mbedtls-2.4.0/library_s/: mbedtls_nsc.c
  group network/ssl/ssl_ram_map
    ../../../component/common/network/ssl/ssl_ram_map/rom/: rom_ssl_ram_map.c
    ../../../component/common/network/ssl/ssl_ram_map/: ssl_ram_map.c
  group os
    ../../../component/os/freertos/: freertos_heap5_config.c freertos_heap_rtk.c
  group os/freertos
    ../../../component/os/freertos/freertos_v10.2.0/Source/portable/IAR/RTL8710C/secure/: secure_context.c secure_context_port.c secure_context_port_asm.s secure_init.c
  group peripheral/api
    ../../../component/common/mbed/targets/hal/rtl8710c/: crypto_api.c reset_reason_api.c sys_api.c
  group peripheral/hal
    ../../../component/soc/realtek/8710c/fwlib/source/ram_s/: hal_efuse.c hal_efuse_nsc.c hal_pinmux_nsc.c
    ../../../component/soc/realtek/8710c/fwlib/source/ram/: hal_gdma.c hal_gpio.c hal_misc.c hal_uart.c
  group user
    ../src/: main_s.c
  group utilities/example
    ../../../component/common/example/secure_storage/: example_secure_storage_s.c
